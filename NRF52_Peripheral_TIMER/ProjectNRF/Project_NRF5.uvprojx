# Keil uVision project Project_NRF5.uvprojx, settings and files
target NRF51-DK (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.3.2
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: NRF51422 +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: __CC_ARM, NRF51
  c include: ..\;..\Libraries\CMSIS;..\Libraries\nRF_Components\nRF_Drivers;..\Libraries\nRF_Components\nRF_Drivers\inc;..\Libraries\nRF_Components\nRF_Libraries\inc;..\Program
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../Libraries/CMSIS/: arm_startup_nrf52.s system_nrf52.c
  group Driver
    ../Program/drivers/: nrf5x_delay.c
    ../Program/: nrf5x_conf.h
  group Program
    ../Program/: main.c nrf5xdk_bsp.c nrf5xdk_it.c
  group nRF_Drivers
    ../Libraries/nRF_Components/nRF_Drivers/common/: nrf_drv_common.c
    ../Libraries/nRF_Components/nRF_Drivers/clock/: nrf_drv_clock.c
    ../Libraries/nRF_Components/nRF_Drivers/timer/: nrf_drv_timer.c
    ../Libraries/nRF_Components/nRF_Drivers/: nrf_drv_config.h
  group nRF_Libraries
    ../Libraries/nRF_Components/nRF_Libraries/util/: app_util_platform.c
target NRF52-DK (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.3.2
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NRF52832 +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: __CC_ARM, NRF52, ARM_MATH_CM4, __FPU_PRESENT = 1
  c include: ..\;..\Libraries\CMSIS;..\Libraries\nRF_Components\nRF_Drivers;..\Libraries\nRF_Components\nRF_Drivers\hal;..\Libraries\nRF_Components\nRF_Drivers\inc;..\Libraries\nRF_Components\nRF_Libraries\inc;..\Program
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
