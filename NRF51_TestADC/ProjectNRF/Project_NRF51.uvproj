# Keil uVision project Project_NRF51.uvproj, settings and files
target NRF51822 (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: NRF51822
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_PCA10001, __CC_ARM
  c include: ..\Libraries;..\Libraries\inc;..\Libraries\src;..\Program;..\Program\Drives;..\Program\Algorithms;..\Program\Modules
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group StartUp
    ../Libraries/: arm_startup_nrf51.s
  group Library
    ../Libraries/: system_nrf51.c
    ../Libraries/src/nrf_delay/: nrf_delay.c
    ../Libraries/src/simple_uart/: simple_uart.c
  group Driver
    ../Program/Drives/: nrf51_delay.c nrf51_adc.c nrf51_uart.c
    ../Program/: nrf51_conf.h
  group Program
    ../Program/: experiment_nrf51.c experiment_nrf51_it.c
  group Modules
    ../Program/Modules/: module_rs232.c
  group Algorithms
    ../Program/Algorithms/: algorithm_string.c
