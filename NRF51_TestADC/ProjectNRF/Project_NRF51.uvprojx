# Keil uVision project Project_NRF51.uvprojx, settings and files
target NRF51422 (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.4
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: NRF51422 +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_PCA10001, __CC_ARM
  c include: ..\Libraries;..\Libraries\inc;..\Libraries\src;..\Program;..\Program\Drives;..\Program\Modules;..\Program\Algorithms
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Driver
    ../Program/Drives/: nrf51_delay.c nrf51_adc.c nrf51_uart.c
    ../Program/: nrf51_conf.h
  group Program
    ../Program/: experiment_nrf51.c experiment_nrf51_it.c
  group Modules
    ../Program/Modules/: module_rs232.c
  group Algorithms
    ../Program/Algorithms/: algorithm_string.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.1, nRF_Drivers:nrf_delay 1.2.1, nRF_Drivers:simple_uart 1.2.1
