# Keil uVision project nRF51_BeaconScan.uvprojx, settings and files
target NRF51_S120_BeaconScan (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.4
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: NRF51422 +hex
  c flags: Optim=1 uC99=1
  c define: __CC_ARM, NRF51, BLE_STACK_SUPPORT_REQD, S120, SOFTDEVICE_PRESENT
  c include: ..\Libraries;..\Libraries\inc;..\Libraries\src;..\Program;..\Program\Drives;..\Program\Modules;..\Program\Algorithms;..\Program\Bluetooth;.\RTE;.\RTE\Device\nRF51422_xxAA
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x27000
  memory RVCT9: RAM 0x20002800 size 0x1800
  group Driver
    ../Program/Drives/: nrf51_delay.c nrf51_uart.c
    ../Program/: nrf51_conf.h
  group Program
    ../Program/: experiment_nrf51.c experiment_nrf51_it.c
  group Bluetooth
    ../Program/Bluetooth/: ble_beaconScan.c
  group Module
    ../Program/Modules/: module_rs232.c
  group Algorithm
    ../Program/Algorithms/: algorithm_string.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.1, nRF_Drivers:nrf_delay 1.2.1, nRF_Drivers:nrf_error 1.2.1, nRF_Libraries:app_error 1.1.1, nRF_Libraries:app_scheduler 1.1.1, nRF_Libraries:app_timer 1.1.1, nRF_Libraries:app_util 1.1.1, nRF_Libraries:nrf_assert 1.1.1, nRF_SoftDevice:Internal:sd_common 1.1.1, nRF_SoftDevice:Internal:softdevice_present 1.1.1, nRF_SoftDevice:s120 1.0.1-3
