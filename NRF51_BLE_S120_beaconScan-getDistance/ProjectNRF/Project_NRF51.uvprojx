# Keil uVision project Project_NRF51.uvprojx, settings and files
target NRF51422 (5060020::V5.06 (build 20)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: NRF51422 +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: __CC_ARM, NRF51, BLE_STACK_SUPPORT_REQD, S120, SOFTDEVICE_PRESENT
  c include: ..\;..\Libraries\CMSIS;..\Libraries\nRF_BLE\3.1.0;..\Libraries\nRF_DeviceFamilyPack\8.2.0;..\Libraries\nRF_Drivers\3.1.0;..\Libraries\nRF_Libraries\3.1.0;..\Libraries\nRF_SoftDevice_S120\2.1.1;..\Libraries\nRF_SoftDevice_Common\1.1.5;..\Program
  library: MicroLIB
  memory RVCT4: ROM 0x1d000 size 0x23000
  memory RVCT9: RAM 0x20002800 size 0x5800
  group CMSIS
    ../Libraries/CMSIS/: arm_startup_nrf51.s system_nrf51.c
  group Library
    ../Libraries/nRF_Drivers/3.1.0/: nrf_delay.c
    ../Program/: nrf51_conf.h
  group Driver
    ../Program/drivers/: nrf51_clock.c nrf51_delay.c nrf51_uart.c
  group Program
    ../Program/: experiment_nrf51.c experiment_nrf51_it.c
  group Bluetooth
    ../Program/bluetooth/: ble_beaconScan.c
  group Module
    ../Program/modules/: module_serial.c
  group Algorithm
    ../Program/algorithms/: algorithm_string.c algorithm_moveAve.c
  group nRF_Libraries
    ../Libraries/nRF_Libraries/3.1.0/: app_error.c app_timer.c
  group nRF_SoftDevice
    ../Libraries/nRF_SoftDevice_Common/1.1.5/: softdevice_handler.c
